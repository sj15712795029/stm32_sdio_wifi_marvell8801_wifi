# Keil uVision project stm32f1_hw.uvprojx, settings and files
target stm32f1_hw (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f1_hw +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ..\..\board\usb_mass_storage;..\..\board;..\..\bsp\core;..\..\bsp\inc;..\..\bsp\STM32_USB-FS-Device_Driver\inc;..\..\component;..\..\component\cjson;..\..\component\fs;..\..\component\fs\fatfs13\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ../../bsp/core/: startup_stm32f10x_hd.s system_stm32f10x.c
  group bsp
    ../../bsp/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../bsp/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group board
    ../../board/: hw_exti.c hw_led.c hw_misc.c hw_oled.c hw_sdio.c hw_spi_flash.c hw_systick.c hw_uart.c hw_button.c hw_sht2x.c hw_wm8960.c
    ../../board/usb_mass_storage/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group fs
    ../../component/fs/: fs_wrapper.c
    ../../component/fs/fatfs13/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group json
    ../../component/cjson/: cJSON.c
  group app
    ./: main.c
