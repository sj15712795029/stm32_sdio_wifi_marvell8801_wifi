# Keil uVision project stm32f1_ucosiii_wifi.uvprojx, settings and files
target stm32f1_ucosiii_wifi (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f1_ucosiii_wifi
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --via .\rtos_conf.opt
  c include: ..\..\bsp\core;..\..\bsp\inc;..\..\board;..\..\kernel;..\..\component;..\..\component\cjson;..\..\component\wifi;..\..\component\lwip\include;..\stm32f1_ucosiii_wifi;..\..\kernel\ucosiii\bsp;..\..\kernel\ucosiii\config;..\..\kernel\ucosiii\cpu;..\..\kernel\ucosiii\cpu\cortex-m3;..\..\kernel\ucosiii\lib;..\..\kernel\ucosiii\uCOS-III\Source;..\..\kernel\ucosiii\uCOS-III\Ports\cortex-m3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ../../bsp/core/: system_stm32f10x.c startup_stm32f10x_hd.s
  group bsp
    ../../bsp/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group kernel
    ../../kernel/: wireless_rtos_wrapper.c
    ../../kernel/ucosiii/bsp/: bsp.c
    ../../kernel/ucosiii/config/: os_app_hooks.c
    ../../kernel/ucosiii/cpu/: cpu_core.c
    ../../kernel/ucosiii/cpu/cortex-m3/: cpu_c.c cpu_a.asm
    ../../kernel/ucosiii/lib/Ports/cortex-m3/: lib_mem_a.asm
    ../../kernel/ucosiii/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../kernel/ucosiii/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_var.c os_tmr.c
    ../../kernel/ucosiii/uCOS-III/Ports/cortex-m3/: os_cpu_c.c os_cpu_a.s
  group wifi
    ../../component/wifi/: marvell88w8801_core.c mrvl88w8801_fw.c
  group json
    ../../component/cjson/: cJSON.c
  group board
    ../../board/: hw_led.c hw_misc.c hw_oled.c hw_sdio.c hw_systick.c hw_uart.c
  group lwip
    ../../component/lwip/apps/httpd/: fs.c httpd.c post_example.c
    ../../component/lwip/apps/mqtt/: mqtt.c
    ../../component/lwip/apps/netbiosns/: netbiosns.c
    ../../component/lwip/apps/ping/: ping.c
    ../../component/lwip/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../component/lwip/core/ipv4/: autoip.c dhcp.c dhcpd.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../component/lwip/netif/: ethernet.c ethernetif.c
  group app
    ./: main.c wifi_app.c
