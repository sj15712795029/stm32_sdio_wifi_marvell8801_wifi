# Keil uVision project stm32f407_marvell8801.uvprojx, settings and files
target stm32f407_marvell8801 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407_marvell8801
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_FULL_LL_DRIVER
  c include: ..\..\bsp\cortex-m4\core;..\..\bsp\cortex-m4\inc;..\..\bsp\cortex-m4\inc\Legacy;..\..\bsp\cortex-m4\STM32_USB_Device_Library\Core\Inc;..\..\bsp\cortex-m4\STM32_USB_Device_Library\Class\MSC\Inc;..\..\board;..\..\board\stm32f407;..\..\board\stm32f407\usb_mass_storage;..\..\component;..\..\component\cjson;..\..\component\wifi;..\..\component\fs;..\..\component\fs;..\..\component\fs\fatfs13\source;..\..\component\lwip\include;..\stm32f407_bb_wifi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group bsp
    ../../bsp/cortex-m4/core/: system_stm32f4xx.c startup_stm32f407xx.s
    ../../bsp/cortex-m4/src/: stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_usb.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_dma.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c
    ../../bsp/cortex-m4/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../bsp/cortex-m4/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group board
    ../../board/stm32f407/: hw_exti.c hw_led.c hw_button.c hw_misc.c hw_sht2x.c hw_spi_flash.c hw_systick.c hw_uart.c hw_sdio.c
    ../../board/stm32f407/usb_mass_storage/: usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c
  group wifi
    ../../component/wifi/: marvell88w8801_core.c mrvl88w8801_fw.c
  group json
    ../../component/cjson/: cJSON.c
  group lwip
    ../../component/lwip/apps/httpd/: fs.c httpd.c post_example.c
    ../../component/lwip/apps/mqtt/: mqtt.c
    ../../component/lwip/apps/netbiosns/: netbiosns.c
    ../../component/lwip/apps/ping/: ping.c
    ../../component/lwip/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../component/lwip/core/ipv4/: autoip.c dhcp.c dhcpd.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../component/lwip/netif/: ethernet.c ethernetif.c
  group app
    ./: main.c wifi_app.c
